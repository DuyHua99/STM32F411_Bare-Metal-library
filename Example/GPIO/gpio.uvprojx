# Keil uVision project gpio.uvprojx, settings and files
target gpio (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gpio +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\Library\GPIO
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source
    ./: main.c
  group Library
    ../../Library/GPIO/: gpio.c gpio.h
software components: CMSIS:CORE 5.2.0, Device:Startup 2.6.2
